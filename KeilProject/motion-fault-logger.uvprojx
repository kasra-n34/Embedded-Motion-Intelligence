# Keil uVision project motion-fault-logger.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: motion-fault-logger
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_MSP432E401Y,__FPU_PRESENT=1
  c include: C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source\ti\devices\msp432e4\inc;.\inc;C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source\ti\devices\msp432e4;.\FreeRTOS\Source\include;.\FreeRTOS\portable\GCC\ARM_CM4F;.\FreeRTOSConfig;.\heap;.\Core,.\Tasks
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: "C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source\ti\devices\msp432e4\driverlib\lib\keil\m4f\msp432e4_driverlib.a"
  group Core
    ./Core/: main.c main_freertos_blink.c sensor_data.h imu.c imu.h sensor_data.c
    C:/ti/simplelink_msp432e4_sdk_4_20_00_12/source/ti/devices/msp432e4/driverlib/: gpio.c sysctl.c
  group FreeRTOS
    ./FreeRTOS/source/: list.c queue.c stream_buffer.c tasks.c timers.c event_groups.c croutine.c
    ./FreeRTOS/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group FreeRTOSConfig
    ./FreeRTOSConfig/: FreeRTOSConfig.h
  group Heap
    ./Heap/: heap_4.c
  group Drivers
    ./inc/: uart.h i2c.h
    ./Drivers/: uart.c i2c.c
  group Tasks
    ./Tasks/: sensor_task.c sensor_task.h logger_task.h logger_task.c ml_task.h ml_task.c
software components: CMSIS:CORE 6.0.0, Device:Startup 3.2.3
